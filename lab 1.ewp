# IAR project lab 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab 1.srec
  ILINK.IlinkOutputFile: lab 1.out
  ILINK.IlinkIcfFile: C:\Users\khale\OneDrive\Skrivbord\Dst2 - kopia\Lab 3\sam3x8-sram_BigHeap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: context_switching_functions_march_2019.s cstartup.s exceptions.c kernel_functions.c main.c startup_sam3x.c system_sam3x.c
